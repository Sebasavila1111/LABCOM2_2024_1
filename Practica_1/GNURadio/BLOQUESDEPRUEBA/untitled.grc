options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):  # solo argumentos predeterminados aquí
              gr.sync_block.__init__(
                  self,
                  name='e_Diff',  # aparecerá en GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.acum_anterior = 0

          def work(self, input_items, output_items):
              x = input_items[0]  # Señal de entrada.
              y0 = output_items[0]  # Señal acumulada diferencial
              N = len(x)
              diff = np.cumsum(x) - self.acum_anterior
              self.acum_anterior = diff[N - 1]
              y0[:] = diff
              return len(y0)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
